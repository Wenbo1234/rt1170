# IAR project hello_world_gpu.ewp, settings and files
configuration Sdram_Debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1176xxxA_M7 NXP MIMXRT1176xxxA_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG
  ICCARM.CCDiagSuppress: Pe1665, Pa092
  ICCARM.CCIncludePath2: ..\..\Source\rtos\amazon-freertos\freertos_kernel\portable\IAR\ARM_CM4F; ..\..\Source\CMSIS\Include; ..\..\Source\rtos\amazon-freertos\freertos_kernel\include; ..\..\Source\devices\MIMXRT1176\drivers\cm7; ..\..\Source\devices\MIMXRT1176\drivers; ..\..\Source\devices\MIMXRT1176; ..\..\Source\devices\MIMXRT1176\utilities; ..\..\Source\devices\MIMXRT1176\utilities\str; ..\..\Source\devices\MIMXRT1176\utilities\debug_console; ..\..\Source\components\uart; ..\..\Source\components\serial_manager; ..\..\Source\components\lists; ..\..\Source\devices\MIMXRT1176\xip; ..\..\Source\demo_src\hello_world; ..\..\Source\board; ..\..\Source\board\xip; ..\..\Source\middleware\usb\include; ..\..\Source\middleware\usb\device; ..\..\Source\middleware\usb\phy; ..\..\Source\components\serial_manager\usb_cdc_adapter; ..\..\Source\components\osa; ..\..\Source\components\common_task; ..\..\Source\demo_src\common; ..\..\Source\components\video; ..\..\Source\components\video\display; ..\..\Source\components\video\display\fbdev; ..\..\Source\components\video\display\dc\lcdifv2; ..\..\Source\components\video\display\dc; ..\..\Source\board\graphic; ..\..\Source\middleware\vglite\inc; ..\..\Source\middleware\vglite\VGLiteKernel; ..\..\Source\middleware\vglite\VGLiteKernel\rtos; ..\..\Source\demo_src\common\graphic; ..\..\Source\demo_src\common\can; ..\..\Source\demo_src\common\audio; ..\..\Source\demo_src\common\led; ..\..\Source\middleware\sdmmc\inc; ..\..\Source\middleware\sdmmc\port; ..\..\Source\middleware\sdmmc\port\usdhc\freertos; ..\..\Source\middleware\sdmmc\src; ..\..\Source\middleware\fatfs\source; ..\..\Source\middleware\fatfs\source\fsl_sd_disk; ..\..\Source\middleware\lwip\port; ..\..\Source\middleware\lwip\src; ..\..\Source\middleware\lwip\src\include; ..\..\Source\middleware\lwip\src\include\lwip; ..\..\Source\middleware\lwip\src\include\lwip\apps; ..\..\Source\middleware\43xxx_Wi-Fi\include; ..\..\Source\middleware\43xxx_Wi-Fi\platforms\MURATA_TYPE1DX; ..\..\Source\middleware\43xxx_Wi-Fi\WICED\network\LwIP\WWD; ..\..\Source\middleware\43xxx_Wi-Fi\WICED\platform; ..\..\Source\middleware\43xxx_Wi-Fi\WICED\platform\include; ..\..\Source\middleware\43xxx_Wi-Fi\WICED\platform\MCU; ..\..\Source\middleware\43xxx_Wi-Fi\WICED\platform\MCU\LPC; ..\..\Source\middleware\43xxx_Wi-Fi\WICED\platform\MCU\LPC\WWD; ..\..\Source\middleware\43xxx_Wi-Fi\WICED\RTOS\FreeRTOS\WWD; ..\..\Source\middleware\43xxx_Wi-Fi\WICED\WWD; ..\..\Source\middleware\43xxx_Wi-Fi\WICED\WWD\include; ..\..\Source\middleware\43xxx_Wi-Fi\WICED\WWD\include\network; ..\..\Source\middleware\43xxx_Wi-Fi\WICED\WWD\include\platform; ..\..\Source\middleware\43xxx_Wi-Fi\WICED\WWD\include\RTOS; ..\..\Source\middleware\43xxx_Wi-Fi\WICED\WWD\internal; ..\..\Source\middleware\43xxx_Wi-Fi\WICED\WWD\internal\bus_protocols\SDIO; ..\..\Source\middleware\43xxx_Wi-Fi\WICED\WWD\internal\chips\4343W; ..\..\Source\middleware\wifi\dhcpd; ..\..\Source\middleware\wifi\incl; ..\..\Source\middleware\wifi\incl\port\lwip; ..\..\Source\middleware\wifi\incl\port\os; ..\..\Source\middleware\wifi\incl\wlcmgr; ..\..\Source\middleware\wifi\incl\wifidriver; ..\..\Source\middleware\wifi\port\lwip; ..\..\Source\middleware\wifi\port\os; ..\..\Source\middleware\wifi\wifi_bt_firmware; ..\..\Source\middleware\wifi\wifidriver; ..\..\Source\middleware\wifi\wifidriver\incl; ..\..\Source\middleware\wifi\wlcmgr
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\Source\demo_src\hello_world
  OBJCOPY.OOCOutputFile: hello_world_gpu.srec
  ILINK.IlinkOutputFile: hello_world_gpu.out
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_sdram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Sdram_Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCDiagSuppress: Pe1665,Pa092
  ICCARM.CCIncludePath2: ..\..\Source\rtos\amazon-freertos\freertos_kernel\portable\IAR\ARM_CM4F; ..\..\Source\CMSIS\Include; ..\..\Source\rtos\amazon-freertos\freertos_kernel\include; ..\..\Source\devices\MIMXRT1176\drivers\cm7; ..\..\Source\devices\MIMXRT1176\drivers; ..\..\Source\devices\MIMXRT1176; ..\..\Source\devices\MIMXRT1176\utilities; ..\..\Source\devices\MIMXRT1176\utilities\str; ..\..\Source\devices\MIMXRT1176\utilities\debug_console; ..\..\Source\components\uart; ..\..\Source\components\serial_manager; ..\..\Source\components\lists; ..\..\Source\devices\MIMXRT1176\xip; ..\..\Source\demo_src\hello_world; ..\..\Source\board; ..\..\Source\board\xip; ..\..\Source\middleware\usb\include; ..\..\Source\middleware\usb\device; ..\..\Source\middleware\usb\phy; ..\..\Source\components\serial_manager\usb_cdc_adapter; ..\..\Source\components\osa; ..\..\Source\components\common_task; ..\..\Source\demo_src\common; ..\..\Source\components\video; ..\..\Source\components\video\display; ..\..\Source\components\video\display\fbdev; ..\..\Source\components\video\display\dc\lcdifv2; ..\..\Source\components\video\display\dc; ..\..\Source\board\graphic; ..\..\Source\middleware\vglite\inc; ..\..\Source\middleware\vglite\VGLiteKernel; ..\..\Source\middleware\vglite\VGLiteKernel\rtos; ..\..\Source\demo_src\common\graphic; ..\..\Source\demo_src\common\can; ..\..\Source\demo_src\common\audio; ..\..\Source\demo_src\common\led; ..\..\Source\middleware\sdmmc\inc; ..\..\Source\middleware\sdmmc\port; ..\..\Source\middleware\sdmmc\port\usdhc\freertos; ..\..\Source\middleware\sdmmc\src; ..\..\Source\middleware\fatfs\source; ..\..\Source\middleware\fatfs\source\fsl_sd_disk; ..\..\Source\middleware\lwip\port; ..\..\Source\middleware\lwip\src; ..\..\Source\middleware\lwip\src\include; ..\..\Source\middleware\lwip\src\include\lwip; ..\..\Source\middleware\lwip\src\include\lwip\apps; ..\..\Source\middleware\43xxx_Wi-Fi\app; ..\..\Source\middleware\43xxx_Wi-Fi\include; ..\..\Source\middleware\43xxx_Wi-Fi\platforms\MURATA_TYPE1DX; ..\..\Source\middleware\43xxx_Wi-Fi\WICED\network\LwIP\WWD; ..\..\Source\middleware\43xxx_Wi-Fi\WICED\platform; ..\..\Source\middleware\43xxx_Wi-Fi\WICED\platform\include; ..\..\Source\middleware\43xxx_Wi-Fi\WICED\platform\MCU; ..\..\Source\middleware\43xxx_Wi-Fi\WICED\platform\MCU\LPC; ..\..\Source\middleware\43xxx_Wi-Fi\WICED\platform\MCU\LPC\WWD; ..\..\Source\middleware\43xxx_Wi-Fi\WICED\RTOS\FreeRTOS\WWD; ..\..\Source\middleware\43xxx_Wi-Fi\WICED\WWD; ..\..\Source\middleware\43xxx_Wi-Fi\WICED\WWD\include; ..\..\Source\middleware\43xxx_Wi-Fi\WICED\WWD\include\network; ..\..\Source\middleware\43xxx_Wi-Fi\WICED\WWD\include\platform; ..\..\Source\middleware\43xxx_Wi-Fi\WICED\WWD\include\RTOS; ..\..\Source\middleware\43xxx_Wi-Fi\WICED\WWD\internal; ..\..\Source\middleware\43xxx_Wi-Fi\WICED\WWD\internal\bus_protocols\SDIO; ..\..\Source\middleware\43xxx_Wi-Fi\WICED\WWD\internal\chips\4343W; ..\..\Source\middleware\wifi\dhcpd; ..\..\Source\middleware\wifi\incl; ..\..\Source\middleware\wifi\incl\port\lwip; ..\..\Source\middleware\wifi\incl\port\os; ..\..\Source\middleware\wifi\incl\wlcmgr; ..\..\Source\middleware\wifi\incl\wifidriver; ..\..\Source\middleware\wifi\port\lwip; ..\..\Source\middleware\wifi\port\os; ..\..\Source\middleware\wifi\wifi_bt_firmware; ..\..\Source\middleware\wifi\wifidriver; ..\..\Source\middleware\wifi\wifidriver\incl; ..\..\Source\middleware\wifi\wlcmgr
  ICCARM.CCOptLevel: 3
configuration Flexspi_Nor_Sdram_Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1
  ICCARM.CCIncludePath2: ..\..\Source\rtos\amazon-freertos\freertos_kernel\portable\IAR\ARM_CM4F; ..\..\Source\CMSIS\Include; ..\..\Source\rtos\amazon-freertos\freertos_kernel\include; ..\..\Source\devices\MIMXRT1176\drivers\cm7; ..\..\Source\devices\MIMXRT1176\drivers; ..\..\Source\devices\MIMXRT1176; ..\..\Source\devices\MIMXRT1176\utilities; ..\..\Source\devices\MIMXRT1176\utilities\str; ..\..\Source\devices\MIMXRT1176\utilities\debug_console; ..\..\Source\components\uart; ..\..\Source\components\serial_manager; ..\..\Source\components\lists; ..\..\Source\devices\MIMXRT1176\xip; ..\..\Source\demo_src\hello_world; ..\..\Source\board; ..\..\Source\board\xip; ..\..\Source\middleware\usb\include; ..\..\Source\middleware\usb\device; ..\..\Source\middleware\usb\phy; ..\..\Source\components\serial_manager\usb_cdc_adapter; ..\..\Source\components\osa; ..\..\Source\components\common_task; ..\..\Source\demo_src\common; ..\..\Source\components\video; ..\..\Source\components\video\display; ..\..\Source\components\video\display\fbdev; ..\..\Source\components\video\display\dc\lcdifv2; ..\..\Source\components\video\display\dc; ..\..\Source\board\graphic; ..\..\Source\middleware\vglite\inc; ..\..\Source\middleware\vglite\VGLiteKernel; ..\..\Source\middleware\vglite\VGLiteKernel\rtos; ..\..\Source\demo_src\common\graphic; ..\..\Source\demo_src\common\can; ..\..\Source\demo_src\common\audio; ..\..\Source\demo_src\common\led; ..\..\Source\middleware\sdmmc\inc; ..\..\Source\middleware\sdmmc\port; ..\..\Source\middleware\sdmmc\port\usdhc\freertos; ..\..\Source\middleware\sdmmc\src; ..\..\Source\middleware\fatfs\source; ..\..\Source\middleware\fatfs\source\fsl_sd_disk; ..\..\Source\middleware\lwip\port; ..\..\Source\middleware\lwip\src; ..\..\Source\middleware\lwip\src\include\lwip; ..\..\Source\middleware\lwip\src\include\lwip\apps; ..\..\Source\middleware\lwip\src\include; ..\..\Source\middleware\43xxx_Wi-Fi\include; ..\..\Source\middleware\43xxx_Wi-Fi\platforms\MURATA_TYPE1DX; ..\..\Source\middleware\43xxx_Wi-Fi\WICED\network\LwIP\WWD; ..\..\Source\middleware\43xxx_Wi-Fi\WICED\platform; ..\..\Source\middleware\43xxx_Wi-Fi\WICED\platform\include; ..\..\Source\middleware\43xxx_Wi-Fi\WICED\platform\MCU; ..\..\Source\middleware\43xxx_Wi-Fi\WICED\platform\MCU\LPC; ..\..\Source\middleware\43xxx_Wi-Fi\WICED\platform\MCU\LPC\WWD; ..\..\Source\middleware\43xxx_Wi-Fi\WICED\RTOS\FreeRTOS\WWD; ..\..\Source\middleware\43xxx_Wi-Fi\WICED\WWD; ..\..\Source\middleware\43xxx_Wi-Fi\WICED\WWD\include; ..\..\Source\middleware\43xxx_Wi-Fi\WICED\WWD\include\network; ..\..\Source\middleware\43xxx_Wi-Fi\WICED\WWD\include\platform; ..\..\Source\middleware\43xxx_Wi-Fi\WICED\WWD\include\RTOS; ..\..\Source\middleware\43xxx_Wi-Fi\WICED\WWD\internal; ..\..\Source\middleware\43xxx_Wi-Fi\WICED\WWD\internal\bus_protocols\SDIO; ..\..\Source\middleware\43xxx_Wi-Fi\WICED\WWD\internal\chips\4343W; ..\..\Source\middleware\wifi\dhcpd; ..\..\Source\middleware\wifi\incl; ..\..\Source\middleware\wifi\incl\port\lwip; ..\..\Source\middleware\wifi\incl\port\os; ..\..\Source\middleware\wifi\incl\wlcmgr; ..\..\Source\middleware\wifi\incl\wifidriver; ..\..\Source\middleware\wifi\port\lwip; ..\..\Source\middleware\wifi\port\os; ..\..\Source\middleware\wifi\wifi_bt_firmware; ..\..\Source\middleware\wifi\wifidriver; ..\..\Source\middleware\wifi\wifidriver\incl; ..\..\Source\middleware\wifi\wlcmgr; ..\..\Source\demo_src\common\eeprom
  OBJCOPY.OOCOutputFile: hello_world_gpu.bin
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_flexspi_nor_sdram.icf
configuration Flexspi_Nor_Sdram_Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; XIP_EXTERNAL_FLASH=1
  ICCARM.CCDiagSuppress: Pe1665,Pa092
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_flexspi_nor_sdram.icf
  group amazon-freertos/freertos_kernel
    ../../Source/rtos/amazon-freertos/freertos_kernel/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group amazon-freertos/freertos_kernel/include
    ../../Source/rtos/amazon-freertos/freertos_kernel/include/: atomic.h deprecated_definitions.h event_groups.h FreeRTOS.h freertos_tasks_c_additions.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h
  group amazon-freertos/freertos_kernel/portable/ARM_CM4F
    ../../Source/rtos/amazon-freertos/freertos_kernel/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group amazon-freertos/freertos_kernel/portable/MemMang
    ../../Source/rtos/amazon-freertos/freertos_kernel/portable/MemMang/: heap_4.c
  group board
    ../../Source/board/: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h usb_device_config.h
  group board/graphic
    ../../Source/board/graphic/: display_support.c display_support.h vglite_support.c vglite_support.h vglite_window.c vglite_window.h
  group board/xip
    ../../Source/board/xip/: dcmimxrt1170_flexspi_nor_config.c dcmimxrt1170_flexspi_nor_config.h evkmimxrt1170_sdram_ini_dcd.c evkmimxrt1170_sdram_ini_dcd.h
  group CMSIS
    ../../Source/CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm7.h mpu_armv7.h
  group component/common_task
    ../../Source/components/common_task/: common_task.c common_task.h
  group component/lists
    ../../Source/components/lists/: generic_list.c generic_list.h
  group component/osa
    ../../Source/components/osa/: fsl_os_abstraction.h fsl_os_abstraction_config.h fsl_os_abstraction_free_rtos.c fsl_os_abstraction_free_rtos.h
  group component/serial_manager
    ../../Source/components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h serial_port_usb.c serial_port_usb.h
  group component/serial_manager/usb_cdc_adapter
    ../../Source/components/serial_manager/usb_cdc_adapter/: usb_device_cdc_acm.c usb_device_cdc_acm.h usb_device_ch9.c usb_device_ch9.h usb_device_class.c usb_device_class.h usb_device_descriptor.c usb_device_descriptor.h
  group component/uart
    ../../Source/components/uart/: lpuart_adapter.c uart.h
  group component/video
    ../../Source/components/video/display/dc/: fsl_dc_fb.h
    ../../Source/components/video/display/dc/lcdifv2/: fsl_dc_fb_lcdifv2.c fsl_dc_fb_lcdifv2.h
    ../../Source/components/video/display/: fsl_display.h
    ../../Source/components/video/display/fbdev/: fsl_fbdev.c fsl_fbdev.h
    ../../Source/components/video/: fsl_video_common.c fsl_video_common.h
  group device
    ../../Source/devices/MIMXRT1176/: fsl_device_registers.h MIMXRT1176_cm7.h MIMXRT1176_cm7_features.h system_MIMXRT1176_cm7.c system_MIMXRT1176_cm7.h
  group device/startup
    ../../Source/devices/MIMXRT1176/iar/: startup_MIMXRT1176_cm7.s
  group device/xip
    ../../Source/devices/MIMXRT1176/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
  group drivers
    ../../Source/devices/MIMXRT1176/drivers/: fsl_anatop.c fsl_anatop.h fsl_anatop_ai.c fsl_anatop_ai.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_dmamux.c fsl_dmamux.h fsl_edma.c fsl_edma.h fsl_flexcan.c fsl_flexcan.h fsl_gpio.c fsl_gpio.h fsl_gpt.c fsl_gpt.h fsl_iomuxc.h fsl_lcdifv2.c fsl_lcdifv2.h fsl_lpi2c.c fsl_lpi2c.h fsl_lpspi.c fsl_lpspi.h fsl_lpuart.c fsl_lpuart.h fsl_sai.c fsl_sai.h fsl_sai_edma.c fsl_sai_edma.h fsl_soc_src.c fsl_soc_src.h fsl_usdhc.c fsl_usdhc.h
    ../../Source/devices/MIMXRT1176/drivers/cm7/: fsl_cache.c fsl_cache.h
  group middleware/43xxx_wifi/include
    ../../Source/middleware/43xxx_Wi-Fi/include/: wiced_resource.h
  group middleware/43xxx_wifi/platforms/MURATA_TYPE1DX
    ../../Source/middleware/43xxx_Wi-Fi/platforms/MURATA_TYPE1DX/: wifi_nvram_image.h
  group middleware/43xxx_wifi/WICED/network/LwIP/WWD
    ../../Source/middleware/43xxx_Wi-Fi/WICED/network/LwIP/WWD/: wwd_buffer.c wwd_buffer.h wwd_network.c wwd_network.h
  group middleware/43xxx_wifi/WICED/platform
    ../../Source/middleware/43xxx_Wi-Fi/WICED/platform/: platform_toolchain.h
  group middleware/43xxx_wifi/WICED/platform/include
    ../../Source/middleware/43xxx_Wi-Fi/WICED/platform/include/: platform_cache_def.h platform_peripheral.h
  group middleware/43xxx_wifi/WICED/platform/MCU
    ../../Source/middleware/43xxx_Wi-Fi/WICED/platform/MCU/: wwd_platform_common.h wwd_platform_separate_mcu.c wwd_resources.c
  group middleware/43xxx_wifi/WICED/platform/MCU/LPC
    ../../Source/middleware/43xxx_Wi-Fi/WICED/platform/MCU/LPC/: platform_mcu_peripheral.h
  group middleware/43xxx_wifi/WICED/platform/MCU/LPC/WWD
    ../../Source/middleware/43xxx_Wi-Fi/WICED/platform/MCU/LPC/WWD/: wwd_platform.c wwd_SDIO.c
  group middleware/43xxx_wifi/WICED/RTOS/FreeRTOS/WWD
    ../../Source/middleware/43xxx_Wi-Fi/WICED/RTOS/FreeRTOS/WWD/: wwd_FreeRTOS_systick.h wwd_rtos.c wwd_rtos.h
  group middleware/43xxx_wifi/WICED/WWD
    ../../Source/middleware/43xxx_Wi-Fi/WICED/WWD/: wwd.h wwd_wiced.h
  group middleware/43xxx_wifi/WICED/WWD/include
    ../../Source/middleware/43xxx_Wi-Fi/WICED/WWD/include/: wwd_assert.h wwd_constants.h wwd_debug.h wwd_eapol.h wwd_events.h wwd_management.h wwd_poll.h wwd_structures.h wwd_wifi.h wwd_wifi_sleep.h wwd_wlioctl.h
  group middleware/43xxx_wifi/WICED/WWD/include/network
    ../../Source/middleware/43xxx_Wi-Fi/WICED/WWD/include/network/: wwd_buffer_interface.h wwd_network_constants.h wwd_network_interface.h
  group middleware/43xxx_wifi/WICED/WWD/include/platform
    ../../Source/middleware/43xxx_Wi-Fi/WICED/WWD/include/platform/: wwd_bus_interface.h wwd_platform_interface.h wwd_resource_interface.h wwd_sdio_interface.h wwd_spi_interface.h
  group middleware/43xxx_wifi/WICED/WWD/include/RTOS
    ../../Source/middleware/43xxx_Wi-Fi/WICED/WWD/include/RTOS/: wwd_rtos_interface.h
  group middleware/43xxx_wifi/WICED/WWD/internal
    ../../Source/middleware/43xxx_Wi-Fi/WICED/WWD/internal/: tlv.c tlv.h wwd_ap.h wwd_ap_common.c wwd_ap_common.h wwd_bcmendian.h wwd_clm.c wwd_clm.h wwd_debug.c wwd_eapol.c wwd_internal.c wwd_internal.h wwd_logging.h wwd_management.c wwd_rtos_interface.c wwd_sdpcm.c wwd_sdpcm.h wwd_thread.c wwd_thread.h wwd_thread_internal.c wwd_thread_internal.h wwd_wifi.c wwd_wifi_chip_common.c wwd_wifi_chip_common.h wwd_wifi_sleep.c
  group middleware/43xxx_wifi/WICED/WWD/internal/bus_protocols
    ../../Source/middleware/43xxx_Wi-Fi/WICED/WWD/internal/bus_protocols/: wwd_bus_common.c wwd_bus_protocol_interface.h
  group middleware/43xxx_wifi/WICED/WWD/internal/bus_protocols/SDIO
    ../../Source/middleware/43xxx_Wi-Fi/WICED/WWD/internal/bus_protocols/SDIO/: wwd_bus_protocol.c wwd_bus_protocol.h
  group middleware/43xxx_wifi/WICED/WWD/internal/chips/4343W
    ../../Source/middleware/43xxx_Wi-Fi/WICED/WWD/internal/chips/4343W/: 4343WA1.h 4343WA1_clm.h 4343WA1_clm_mfg.h 4343WA1_mfg.h chip_constants.h resources.c resources.h wwd_ap.c wwd_chip_specific_functions.c
  group middleware/fatfs
    ../../Source/middleware/fatfs/source/: diskio.c diskio.h ff.c ff.h ffsystem.c ffunicode.c
  group middleware/fatfs/fsl_sd_disk
    ../../Source/middleware/fatfs/source/fsl_sd_disk/: fsl_sd_disk.c fsl_sd_disk.h
  group middleware/lwip/port
    ../../Source/middleware/lwip/port/: sys_arch.c
  group middleware/lwip/port/arch
    ../../Source/middleware/lwip/port/arch/: cc.h perf.h sys_arch.h
  group middleware/lwip/src/api
    ../../Source/middleware/lwip/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group middleware/lwip/src/apps/lwiperf
    ../../Source/middleware/lwip/src/apps/lwiperf/: lwiperf.c
  group middleware/lwip/src/core
    ../../Source/middleware/lwip/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group middleware/lwip/src/core/ipv4
    ../../Source/middleware/lwip/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group middleware/lwip/src/core/ipv6
    ../../Source/middleware/lwip/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group middleware/lwip/src/include/compat/posix
    ../../Source/middleware/lwip/src/include/compat/posix/: netdb.h
  group middleware/lwip/src/include/compat/posix/arpa
    ../../Source/middleware/lwip/src/include/compat/posix/arpa/: inet.h
  group middleware/lwip/src/include/compat/posix/net
    ../../Source/middleware/lwip/src/include/compat/posix/net/: if.h
  group middleware/lwip/src/include/compat/posix/sys
    ../../Source/middleware/lwip/src/include/compat/posix/sys/: socket.h
  group middleware/lwip/src/include/compat/stdc
    ../../Source/middleware/lwip/src/include/compat/stdc/: errno.h
  group middleware/lwip/src/include/lwip
    ../../Source/middleware/lwip/src/include/lwip/: altcp.h altcp_tcp.h altcp_tls.h api.h arch.h autoip.h debug.h def.h dhcp.h dhcp6.h dns.h err.h errno.h etharp.h ethip6.h icmp.h icmp6.h if_api.h igmp.h inet.h inet_chksum.h init.h ip.h ip4.h ip4_addr.h ip4_frag.h ip6.h ip6_addr.h ip6_frag.h ip6_zone.h ip_addr.h mem.h memp.h mld6.h nd6.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h sockets.h stats.h sys.h tcp.h tcpbase.h tcpip.h timeouts.h udp.h
  group middleware/lwip/src/include/lwip/apps
    ../../Source/middleware/lwip/src/include/lwip/apps/: lwiperf.h
  group middleware/lwip/src/include/lwip/priv
    ../../Source/middleware/lwip/src/include/lwip/priv/: altcp_priv.h api_msg.h mem_priv.h memp_priv.h memp_std.h nd6_priv.h raw_priv.h sockets_priv.h tcp_priv.h tcpip_priv.h
  group middleware/lwip/src/include/lwip/prot
    ../../Source/middleware/lwip/src/include/lwip/prot/: autoip.h dhcp.h dhcp6.h dns.h etharp.h ethernet.h iana.h icmp.h icmp6.h ieee.h igmp.h ip.h ip4.h ip6.h mld6.h nd6.h tcp.h udp.h
  group middleware/lwip/src/include/netif
    ../../Source/middleware/lwip/src/include/netif/: bridgeif.h bridgeif_opts.h etharp.h ethernet.h ieee802154.h lowpan6.h lowpan6_ble.h lowpan6_common.h lowpan6_opts.h slipif.h zepif.h
  group middleware/lwip/src/include/netif/ppp
    ../../Source/middleware/lwip/src/include/netif/ppp/: ccp.h chap-md5.h chap-new.h chap_ms.h eap.h ecp.h eui64.h fsm.h ipcp.h ipv6cp.h lcp.h magic.h mppe.h ppp.h ppp_impl.h ppp_opts.h pppapi.h pppcrypt.h pppdebug.h pppoe.h pppol2tp.h pppos.h upap.h vj.h
  group middleware/lwip/src/include/netif/ppp/polarssl
    ../../Source/middleware/lwip/src/include/netif/ppp/polarssl/: arc4.h des.h md4.h md5.h sha1.h
  group middleware/lwip/src/netif
    ../../Source/middleware/lwip/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
  group middleware/lwip/src/netif/ppp
    ../../Source/middleware/lwip/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c lwip_ecp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
  group middleware/sdmmc/inc
    ../../Source/middleware/sdmmc/inc/: fsl_sd.h fsl_sdio.h fsl_sdmmc_common.h fsl_sdmmc_host.h fsl_sdmmc_spec.h
  group middleware/sdmmc/port
    ../../Source/middleware/sdmmc/port/usdhc/freertos/: fsl_sdmmc_event.c fsl_sdmmc_host.c
    ../../Source/middleware/sdmmc/port/: fsl_sdmmc_event.h
  group middleware/sdmmc/src
    ../../Source/middleware/sdmmc/src/: fsl_sd.c fsl_sdio.c fsl_sdmmc_common.c
  group middleware/usb/device
    ../../Source/middleware/usb/device/: usb_device.h usb_device_dci.c usb_device_dci.h usb_device_ehci.c usb_device_ehci.h
  group middleware/usb/include
    ../../Source/middleware/usb/include/: usb.h usb_misc.h usb_spec.h
  group middleware/usb/phy
    ../../Source/middleware/usb/phy/: usb_phy.c usb_phy.h
  group middleware/vglite/inc
    ../../Source/middleware/vglite/inc/: vg_lite.h vg_lite_hal.h
  group middleware/vglite/VGLite
    ../../Source/middleware/vglite/VGLite/: vg_lite.c vg_lite_image.c vg_lite_matrix.c vg_lite_path.c
  group middleware/vglite/VGLiteKernel
    ../../Source/middleware/vglite/VGLiteKernel/: vg_lite_hw.h vg_lite_kernel.c vg_lite_kernel.h
  group middleware/vglite/VGLiteKernel/rtos
    ../../Source/middleware/vglite/VGLiteKernel/rtos/: vg_lite_hal.c vg_lite_platform.h
  group middleware/wifi/dhcpd
    ../../Source/middleware/wifi/dhcpd/: dhcp-bootp.h dhcp-priv.h dhcp-server-main.c dhcp-server.c dns-server.c dns.h
  group middleware/wifi/incl
    ../../Source/middleware/wifi/incl/: dhcp-server.h wm_utils.h wmerrno.h wmlog.h
  group middleware/wifi/incl/port/lwip
    ../../Source/middleware/wifi/incl/port/lwip/: wm_net.h
  group middleware/wifi/incl/port/os
    ../../Source/middleware/wifi/incl/port/os/: wm_os.h
  group middleware/wifi/incl/wifidriver
    ../../Source/middleware/wifi/incl/wifidriver/: mdev.h mdev_sdio.h wifi-decl.h wifi.h wifi_events.h
  group middleware/wifi/incl/wlcmgr
    ../../Source/middleware/wifi/incl/wlcmgr/: wlan.h wlan_11d.h
  group middleware/wifi/port/lwip
    ../../Source/middleware/wifi/port/lwip/: net.c netif_decl.h wifi_netif.c
  group middleware/wifi/port/os
    ../../Source/middleware/wifi/port/os/: os.c
  group middleware/wifi/wifi_bt_firmware
    ../../Source/middleware/wifi/wifi_bt_firmware/: sd8801_wlan.h sduart8977_wlan_bt.h
  group middleware/wifi/wifidriver
    ../../Source/middleware/wifi/wifidriver/: mdev_sdio.c mlan_11ac.c mlan_11d.c mlan_11h.c mlan_11n.c mlan_11n_aggr.c mlan_11n_rxreorder.c mlan_cfp.c mlan_cmdevt.c mlan_glue.c mlan_init.c mlan_join.c mlan_misc.c mlan_scan.c mlan_shim.c mlan_sta_cmd.c mlan_sta_cmdresp.c mlan_sta_event.c mlan_sta_ioctl.c mlan_sta_rx.c mlan_txrx.c mlan_uap_cmdevent.c mlan_uap_ioctl.c mlan_wmm.c mlan_wmsdk.c wifi-debug.c wifi-debug.h wifi-internal.h wifi-mem.c wifi-sdio.c wifi-sdio.h wifi-uap.c wifi.c wifi_common.h wifi_pwrmgr.c
  group middleware/wifi/wifidriver/incl
    ../../Source/middleware/wifi/wifidriver/incl/: mlan.h mlan_11ac.h mlan_11h.h mlan_11n.h mlan_11n_aggr.h mlan_11n_rxreorder.h mlan_decl.h mlan_fw.h mlan_ieee.h mlan_init.h mlan_ioctl.h mlan_join.h mlan_main.h mlan_meas.h mlan_remap_mem_operations.h mlan_sdio.h mlan_uap.h mlan_util.h mlan_wmm.h mlan_wmsdk.h
  group middleware/wifi/wlcmgr
    ../../Source/middleware/wifi/wlcmgr/: wlan.c
  group source
    ../../Source/demo_src/hello_world/: appconfig.h ffconf.h FreeRTOSConfig.h hello_world.c lpuart_gps.c lpuart_gps.h lwipopts.h lwippools.h sd_card.c tiger_freertos.c tiger_paths.h wiced_iperf_4343w.c wiced_iperf_sd8801.c wifi_config.h
    ../../Source/demo_src/common/: shell.c
  group source/audio
    ../../Source/demo_src/common/audio/: audio.c audio.h music.h
  group source/can
    ../../Source/demo_src/common/can/: flexcan_loopback.c flexcan_loopback.h
  group source/common
    ../../Source/demo_src/common/: logging.c logging.h shell_color.h syscmd.c syscmd.h
  group source/eeprom
    ../../Source/demo_src/common/eeprom/: i2c_eeprom.c i2c_eeprom.h
  group source/led
    ../../Source/demo_src/common/led/: led.c led.h
  group utilities
    ../../Source/devices/MIMXRT1176/utilities/: fsl_assert.c fsl_shell.c fsl_shell.h
    ../../Source/devices/MIMXRT1176/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../Source/devices/MIMXRT1176/utilities/str/: fsl_str.c fsl_str.h
